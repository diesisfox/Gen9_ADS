<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Gen9_ADS.ewp</path>
  </project>
  <batchBuild />
</workspace>
